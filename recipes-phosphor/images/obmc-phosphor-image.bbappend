IMAGE_INSTALL:append = " packagegroup-snow-mctp"
